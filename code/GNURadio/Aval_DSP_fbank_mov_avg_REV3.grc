<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Aval_DSP_fbank_mov_avg</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandpass_taps</value></param>
<param><key>value</key><value>firdes.complex_band_pass (1, samp_rate_decimated, -1*cutoff_fbank, cutoff_fbank, transition_bw_fbank, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bp_decimation</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>457e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_offset</value></param>
<param><key>value</key><value>120</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_fbank</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_total</value></param>
<param><key>value</key><value>200*8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>768000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_decimated</value></param>
<param><key>value</key><value>samp_rate/decim_total</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition_bw</value></param>
<param><key>value</key><value>samp_rate_decimated/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition_bw_fbank</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vect_size</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>airspyhf_source</key>
<param><key>id</key><value>airspyhf_source_0</value></param>
<param><key>att_gain0</key><value>0</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>freq0</key><value>457000</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>lna_gain0</key><value>10</value></param>
<param><key>args</key><value>C852A98040343FD2</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>num_mboards</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>airspyhf_source</key>
<param><key>id</key><value>airspyhf_source_0_0</value></param>
<param><key>att_gain0</key><value>0</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>freq0</key><value>457000</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>lna_gain0</key><value>10</value></param>
<param><key>args</key><value>C852D65D9DBF34DD</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>num_mboards</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>2*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>0*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-4*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-6*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>3*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>1*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>4*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>2*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>5*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>3*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>6*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>4*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>0*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-2*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>0*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-2*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0_0_1</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>6*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>4*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0_1</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-3*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0_1_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-3*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_0_2</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>5*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>3*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_1</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-2*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-4*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_1_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-2*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-4*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_0_2</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>4*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>2*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_1</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-3*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-5*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_1_0</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-3*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-5*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_0_2</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>3*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>1*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0_1</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-4*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-6*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_1</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>2*cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>0*cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_1</value></param>
<param><key>decim</key><value>bp_decimation</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>cutoff_fbank-center_freq_offset</value></param>
<param><key>low_cutoff_freq</key><value>-cutoff_fbank-center_freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_decimated</value></param>
<param><key>width</key><value>transition_bw_fbank</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_2</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_2_0</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size</value></param>
<param><key>num_inputs</key><value>11</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>lengths</key><value>vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size,vect_size</value></param>
<param><key>num_inputs</key><value>11</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>11*vect_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>11*vect_size</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_DEC_LP</value></param>
<param><key>center_freq</key><value>center_freq_offset</value></param>
<param><key>decim</key><value>decim_total</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, samp_rate_decimated*0.5,transition_bw, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_DEC_LP_0</value></param>
<param><key>center_freq</key><value>120</value></param>
<param><key>decim</key><value>decim_total</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, samp_rate_decimated*0.5,transition_bw, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>address</key><value>"tcp://127.0.0.1:5555"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>11*vect_size</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0</value></param>
<param><key>address</key><value>"tcp://127.0.0.1:5556"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>11*vect_size</value></param>
</block>
<connection><source_block_id>airspyhf_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_DEC_LP</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>airspyhf_source_0_0</source_block_id><sink_block_id>freq_xlating_fir_filter_DEC_LP_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_0_2</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_0_2</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_0_2</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_1</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_2</source_block_id><sink_block_id>blocks_stream_to_vector_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_2_0</source_block_id><sink_block_id>blocks_stream_to_vector_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_0_0</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_0_0_0</source_block_id><sink_block_id>zeromq_push_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_DEC_LP_0</source_block_id><sink_block_id>band_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
