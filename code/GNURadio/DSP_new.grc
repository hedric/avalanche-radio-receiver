<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>DSP_new</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Xlating_fir_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, samp_rate_decimated*0.5,transition_bw, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>457e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_total</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>768000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_decimated</value></param>
<param><key>value</key><value>samp_rate/decim_total</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition_bw</value></param>
<param><key>value</key><value>samp_rate_decimated/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vect_size</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>airspyhf_source</key>
<param><key>id</key><value>airspyhf_source_0</value></param>
<param><key>att_gain0</key><value>0</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>lna_gain0</key><value>6</value></param>
<param><key>args</key><value>airspyhf=0</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>num_mboards</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>decim_total</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>Xlating_fir_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>25</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_total</value></param>
<param><key>title</key><value>FFT</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>airspyhf_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
